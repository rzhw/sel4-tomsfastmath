## Kconfig
```kconfig
config LIB_TOMSFASTMATH
    bool "TomsFastMath"
    depends on HAVE_LIBC
    default y
    help
        TomsFastMath
```
